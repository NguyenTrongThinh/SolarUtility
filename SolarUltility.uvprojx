# Keil uVision project SolarUltility.uvprojx, settings and files
target SolarUltility (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SolarUltility +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\Driver;.\Application;.\System\FreeRTOS\include;.\System\FreeRTOS\portable\MemMang;.\System\FreeRTOS\portable\RVDS\ARM_CM3;.\System\Libraries\CMSIS\CM3\CoreSupport;.\System\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\System\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Application/: main.c xTask.c
  group FreeRTOS
    ./System/FreeRTOS/: list.c queue.c tasks.c timers.c
    ./System/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./System/FreeRTOS/portable/MemMang/: heap_2.c
  group Driver
    ./Driver/: crystalconfig.c relay.c buzzer.c bluetooth.c button.c
  group Library
    ./System/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./System/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./System/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ./System/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c
